# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SYSTEM;..\HARDWARE
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/: delay.c GPIO.c I2C.c UART.C
  group HARDWARE
    ../HARDWARE/: LCD1602.c SHT30.c protocol.c mcu_api.c system.c
